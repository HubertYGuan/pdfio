## zephyr/Kconfig
```kconfig
config PDFIO
	bool "Enable PDFio"
	default n
	depends on ZLIB
	help
	  This option enables PDFio as a Zephyr module.
```
